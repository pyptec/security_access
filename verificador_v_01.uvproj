# Keil uVision project verificador_v_01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: expedidor_v_105_raspberry_horarios +hex
  c flags: Optimize=8 SizeSpeed=1
  group Expedidor
    ./: main.c Accescan.c Clock.c delay.c eeprom.c io_sensores.c pantallas.c prog.c pto_paralelo.c tibbo.c uart.c lintech.c verificador.c Monitor.c
  group Documentacion
    ./: Documentacion.txt
